# Keil uVision project LaneController_STM32.uvprojx, settings and files
target VE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LaneController_STM32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\IIC;..\..\User\Key;..\..\User\LED;..\..\User\motor;..\..\User\SysTick;..\..\User\usart;..\..\User\device_control;..\..\User\extwdt;..\..\User\message_handle;..\..\User\spi;..\..\User\debug;..\..\User\sys;..\..\User\ATE_shell
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c stm32f10x.h system_stm32f10x.c core_cm3.h system_stm32f10x.h
  group FWLIB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: init.c main.c stm32f10x_conf.h time.c stm32f10x_it.c test.c usart_driver.c
    ../../User/Key/: bsp_key.c
    ../../User/LED/: bsp_led.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/usart/: bsp_usart2.c bsp_usart1.c
    ../../User/extwdt/: ext_wdt.c
    ../../User/device_control/: dev_ctrl.c
    ../../User/message_handle/: message_handle.c
    ../../User/spi/: spi.c w25qxx.c
    ../../User/debug/: debug.c
    ../../User/sys/: sys.c
    ../../User/ATE_shell/: ATE_Shell.C xmodem.c
  group DOC
    ../../Doc/: readme.txt
    ../../User/: 官方例程IO.txt
